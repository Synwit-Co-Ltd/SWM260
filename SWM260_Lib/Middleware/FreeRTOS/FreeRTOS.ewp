# IAR project FreeRTOS.ewp, settings and files
configuration SWM260 (ARM, debug)
  General.OGChipSelectEditMenu: SWM260xB Synwit SWM260xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\SWM260_StdPeriph_Driver\CSL\CMSIS\CoreSupport; ..\..\SWM260_StdPeriph_Driver\CSL\CMSIS\DeviceSupport; ..\..\SWM260_StdPeriph_Driver\CSL\SWM260_StdPeriph_Driver; .\APP\FreeRTOS; .\APP\FreeRTOS\port_IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: APP/FreeRTOS
  OBJCOPY.OOCOutputFile: SWM2400_StdPeriph_Driver.srec
  ILINK.IlinkOutputFile: FreeRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CSL_StdPD
    ../../SWM260_StdPeriph_Driver/CSL/SWM260_StdPeriph_Driver/: SWM260_rtc.c SWM260_exti.c SWM260_dma.c SWM260_uart.c SWM260_i2c.c SWM260_timr.c SWM260_flash.c SWM260_adc.c SWM260_wdt.c SWM260_spi.c SWM260_port.c SWM260_pwm.c SWM260_gpio.c
  group CSL_CMSIS
    ../../SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/iar/: startup_SWM260.s
    ../../SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM260.c
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: tasks.c queue.c list.c
    ./APP/FreeRTOS/port_IAR/: port.c portasm.s
    ./APP/FreeRTOS/heap/: heap_1.c
