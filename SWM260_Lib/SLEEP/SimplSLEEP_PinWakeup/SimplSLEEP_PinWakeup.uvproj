# Keil uVision project SimplSLEEP_PinWakeup.uvproj, settings and files
target SWM260 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SimplSLEEP_PinWakeup
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2
  c include: ..\..\SWM260_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM260_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM260_StdPeriph_Driver\CSL\SWM260_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM260_StdPeriph_Driver/CSL/SWM260_StdPeriph_Driver/: SWM260_adc.c SWM260_exti.c SWM260_gpio.c SWM260_i2c.c SWM260_pwm.c SWM260_timr.c SWM260_uart.c SWM260_wdt.c SWM260_dma.c SWM260_flash.c SWM260_port.c SWM260_spi.c SWM260_rtc.c SWM260_sleep.c
  group CSL\CMSIS
    ../../SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM260.c
    ../../SWM260_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM260.s
